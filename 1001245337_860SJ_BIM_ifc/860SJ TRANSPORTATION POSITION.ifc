Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2020-11-14T20:36:57
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190108_1515(x64) - Exporter 19.2.1.1 - Alternate UI 19.2.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Nov 14 20:36:57 2020 * Host: CHTSL10017 * Database: C:\Users\174900\AppData\Local\Temp\{68815785-153A-4E53-B8E3-ED9FE5C7C4E0}\ifc * Database version: 5507 * Database creation date: Sat Nov 14 20:36:48 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Nov 14 20:36:48 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Nov 14 20:36:48 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcTransportElement: Height=0.06m(0'-2")_Reach=8.28m(27'-2")_(Platform Rotation 90°), 1001245337_860SJ:Height=0.06m(0'-2")_Reach=8.28m(27'-2")_(Platform Rotation 90°):264164
In: Level 1
Type - Material: JLG_Plastic_Blue, JLG_Plastic_Green, JLG_Paint_Black, JLG_Plastic_Yellow, JLG_Paint_Orange, JLG_Metal Paint_White, JLG_Metal Paint_Black, JLG_Paint_White, JLG_Paint_Silver Grey, JLG_Steel, JLG_Paint_Beige, JLG_Plastic_Red, 001_Body Color1, JLG_Rubber_Black
Type - Constraints - Aa: 4.7 deg; AE: 31 mm; AEa: -5.9 deg; Ja: -60.6 deg; P227: yes; P340: yes; Reach: 1
Type - Data - Auxiliary Power: 12v DC; Axle Oscillation: 0.17m (0 ft- 6.8 in); Diesel Engine: DEUTZ T4F (67 HP (50 kW) DEUTZ T4I (48.8 HP (36.4 kW) FORD GASOLINE (84 HP (62 kW) FORD LP (80 HP (59 kW); Drive Speed 2WD/4WD: 5.6 kph (3.5 mph); Fuel Tank Capacity: 117.3 L (31 gal); Gradeability 2WD: 25%; Gradeability 4WD: 45%; Horizontal Outreach (Restricted): 18.18m (59 ft - 7.9 in); Horizontal Outreach (Unrestricted): 22.78m (74 ft - 8.9 in); Hydraulic Tank Capacity: 181.7 L (48 gal); Jib - Overall Length: 1.83 m (6 ft 0 in); Jib Range of Articulation: 131.1 Degrees (+70.5 / - 60.6); Machine weight (ANSI): 16,710 kg (36,840 lbs); Machine weight (CE): 16,710Kg / 36,840 lbs; Max Ground Bearing Pressure (ANSI): 5.69 kg/cm2 (81 psi); Max Ground Bearing Pressure (CE): 5.69 kg/cm2 (81 psi); Model Name: 860SJ; Platform Capacity restricted (ANSI): 340 kg (750 lbs); Platform Capacity restricted (CE): 340 kg (750 lbs); Platform Capacity Unrestricted (ANSI): 227 kg (500 lbs); Platform Capacity Unrestricted (CE): 230kg; Platform Height (Restricted): 26.25m (86 ft-1.5in); Platform Height (Unrestricted): 26.25m (86 ft-1.5in); Platform Rotator (Hydraulic): 180 Degrees; Platform Size: 0.91 x 2.44 m (3 ft 0 in x 8 ft 0 in); Swing: 360 Degrees Continuous; Turning Radius Inside (2WS): 2WS - 3.81 m (12 ft-5.25 in); Turning Radius Outside (2WS): 6.0 m (19 ft-8.8 in); Tyres: 18-625 FF
Type - Dimensions - Aa1: 184.7 deg; AEa1: 174.1 deg; AHa: -4.7 deg; AHa1: 175.3 deg; Ja1: 119.4 deg; JHa: 5.9 deg; JHa1: 185.9 deg; PHa: 60.6 deg; PHa1: 240.6 deg
Type - General - Articulating Jib: 1.83 m articulating jib; Platform Rotator .: 180 degree powered platform rotator; Platform Side Entry: 0.91 m x 2.44 m (3 ft 0 in x 8 ft 0 in); Tilt Alarm/Indicator Light: 4 Degrees
Type - Identity Data - Manufacturer: JLG; OmniClass Number: 23.40.00.00; OmniClass Title: Equipment and Furnishings; Type Name: Height=0.06m(0'-2")_Reach=8.28m(27'-2")_(Platform Rotation 90°); URL: https://www.jlg.com
Type - Model Properties - _Author: n/a; _AuthorizedBy: n/a; _BIMspec_GUID: n/a; _BimSpecGuid: n/a; _BSBibleVersion: n/a; _CreatedBy: JLG; _CurrentRevision: 0; _DistributedBy: JLG; BIMObjectName: 1001245337_860SJ; NBSDescription: Telescopic boom lifts; NBSNote: n/a; NBSObjectName: JLG 860SJ_Telescopic boom lifts; NBSOfficeMasterTag: n/a; NBSReference: n/a
Type - Other - Category: Mechanical Equipment; AccessibilityPerformance: n/a; AssetIdentifier (default): Please Record On Commissioning; AssetType: Elevators; BarCode (default): Please Record On Commissioning; ClassificationName: n/a; ClassificationValue: n/a; CodePerformance: n/a; Color: n/a; Constituents: n/a; CreatedBy: JLG (https://www.jlg.com/en); CreatedOn: 2018; DocumentationCertificates: n/a; DocumentationInstallationGuide: n/a; DocumentationLiterature: n/a; DocumentationMaintenance: n/a; DocumentationTechnical: n/a; DurationUnit: Years; ExpectedLife: n/a; Family Name: 1001245337_860SJ; Features: n/a; Finish: n/a; Grade: n/a; InstallationDate (default): n/a; ManufacturerName: JLG (https://www.jlg.com/en); Material: n/a; ModelNumber: 860SJ; ModelReference: JLG - Articulating Boom Lift; ProductionYear: n/a; ReferencedStandard: n/a; ReplacementCost: n/a; SerialNumber (default): Please Record On Commissioning; Shape: n/a; Size: n/a; SpareParts: n/a; TypeName: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: https://www.jlg.com; WarrantyGuarantorParts: https://www.jlg.com
OperationType: ELEVATOR; CapacityByWeight: 0 kg; CapacityByNumber: 0
Pset_ManufacturerTypeInformation - ModelReference: JLG - Articulating Boom Lift; Manufacturer: JLG; ProductionYear: n/a
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm; P2: no; P3: no
Dimensions - Area: 1189.94 m2; Platform Rotation: 90 deg; PR: 90 deg; Reach Diagram: no; Sa1: 180 deg; Swing_Angle: 0 deg; Turning Radius: no; Volume: 5.16522 m3; Working Area: no
Identity Data - Mark: 3
Other - Family: 1001245337_860SJ: Height=0.06m(0'-2")_Reach=8.28m(27'-2")_(Platform Rotation 90°); Family and Type: 1001245337_860SJ: Height=0.06m(0'-2")_Reach=8.28m(27'-2")_(Platform Rotation 90°); Type: 1001245337_860SJ: Height=0.06m(0'-2")_Reach=8.28m(27'-2")_(Platform Rotation 90°); Type Id: 1001245337_860SJ: Height=0.06m(0'-2")_Reach=8.28m(27'-2")_(Platform Rotation 90°); WarrantyStartDate (default): Please Record On Commissioning
Phasing - Phase Created: New Construction
